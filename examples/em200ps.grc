options:
  parameters:
    description: 'Panorama scan (PScan) del R&S EM200: barrido en vivo y promedio.'
    generate_options: qt_gui
    id: em200ps
    output_language: python
    title: EM200 - Panorama Scan
  states: {}

blocks:
- name: avg_alpha
  id: variable_qtgui_range
  parameters:
    comment: Peso del promedio exponencial (1 = sin promediar)
    gui_hint: 0,0,1,1
    label: Promedio (alfa)
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: f_start
  id: variable
  parameters:
    comment: Frecuencia inicial (Hz). Cambiar y volver a ejecutar
    value: 88e6
  states: {}
- name: f_stop
  id: variable
  parameters:
    comment: Frecuencia final (Hz)
    value: 108e6
  states: {}
- name: npoints
  id: variable
  parameters:
    comment: Puntos por barrido
    value: int(round((f_stop - f_start) / step)) + 1
  states: {}
- name: step
  id: variable
  parameters:
    comment: 'Paso / RBW (Hz). Validos: 100, 125, 200, 250, 500, 625, 1k, 1.25k, 2k, 2.5k, 3.125k, 5k, 6.25k, 8.333k, 10k, 12.5k, 20k, 25k, 50k, 100k, 200k, 500k, 1M, 2M'
    value: 25e3
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Habilitalo para ver en consola el pico de cada barrido
  states: {state: disabled}
- name: em200_pscan_source_0
  id: em200_pscan_source
  parameters:
    ip: 192.168.29.200
    port: '5555'
    progressive: 'True'
    refresh: '0.2'
    duplicate: 'True'
    restore: 'True'
    start: f_start
    step: step
    stop: f_stop
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Barrido
    label2: Promedio
    name: '"Panorama Scan EM200"'
    nconnections: '2'
    vlen: npoints
    width2: '2'
    x_axis_label: '"Frecuencia"'
    x_start: f_start / 1e6
    x_step: step / 1e6
    x_units: '"MHz"'
    y_axis_label: '"Nivel"'
    y_units: '"dBuV"'
    ymax: '100'
    ymin: '-10'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: avg_alpha
    comment: Promedio exponencial barrido a barrido
    type: float
    vlen: npoints
  states: {}

connections:
- [em200_pscan_source_0, '0', qtgui_vector_sink_f_0, '0']
- [em200_pscan_source_0, '0', single_pole_iir_filter_xx_0, '0']
- [em200_pscan_source_0, sweep, blocks_message_debug_0, print]
- [single_pole_iir_filter_xx_0, '0', qtgui_vector_sink_f_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
