options:
  parameters:
    description: Receptor de FM comercial con el IQ del R&S EM200 por Ethernet (BW 300 kHz -> 400 kS/s).
    generate_options: qt_gui
    id: em200_fm
    output_language: python
    title: EM200 - Receptor FM
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bw
  id: variable_qtgui_chooser
  parameters:
    comment: Ancho de banda de demodulacion del EM200 (filtro IF real del equipo). 300 kHz cubre un canal de FM comercial completo.
    gui_hint: 1,1,1,1
    label: Ancho de banda demod.
    labels: '["120 kHz", "150 kHz", "250 kHz", "300 kHz", "500 kHz"]'
    num_opts: '0'
    options: '[120e3, 150e3, 250e3, 300e3, 500e3]'
    type: real
    value: 300e3
  states: {}
- name: demod_rate
  id: variable
  parameters:
    comment: Tasa fija de la cadena de demodulacion
    value: 400e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frecuencia (Hz)
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 90.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Tasa IQ del EM200 para bw (120-150 kHz -> 200 kS/s, 250-300 kHz -> 400 kS/s, 500 kHz -> 800 kS/s)
    value: em200.sample_rate(bw)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Volumen
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    comment: 'Demodulador FM de banda ancha con de-enfasis: 400 kS/s -> 50 kS/s'
    quad_rate: demod_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: em200_iq_source_0
  id: em200_iq_source
  parameters:
    bandwidth: bw
    buffer_seconds: '2.0'
    freq: freq
    if_mode: '"SHORT"'
    ip: 192.168.29.200
    port: '5555'
    restore: 'True'
  states: {}
- name: import_em200
  id: import
  parameters:
    imports: import em200
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: Lleva la tasa del EM200 (variable segun bw) a 400 kS/s fijos; se ajusta en caliente
    nfilts: '32'
    rrate: demod_rate / samp_rate
    taps: firdes.low_pass(32, 32 * samp_rate, 0.4 * min(samp_rate, demod_rate), 0.1 * min(samp_rate, demod_rate))
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: '"Espectro RF"'
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_rate
    color1: '"red"'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 2,1,1,1
    legend: 'False'
    name: '"Espectro de audio"'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0,1,2
    int_max: '0'
    legend: 'False'
    name: '"Waterfall RF"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 50 kS/s -> 48 kS/s
    decim: '50'
    interp: '48'
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_1, '0']
- [em200_iq_source_0, '0', pfb_arb_resampler_xxx_0, '0']
- [em200_iq_source_0, '0', qtgui_freq_sink_x_0, '0']
- [em200_iq_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
