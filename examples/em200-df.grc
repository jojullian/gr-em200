options:
  parameters:
    description: 'Radiogoniometria con el R&S EM200 (traza DFPan): compas, azimut, calidad y nivel en vivo.'
    generate_options: qt_gui
    id: em200_df
    output_language: python
    title: EM200 - Radiogoniometro
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: Frecuencia (Hz)
    start: 20e6
    step: 12.5e3
    stop: 8e9
    value: 145e6
  states: {}
- name: df_bw
  id: variable_qtgui_chooser
  parameters:
    comment: 'Ancho de banda DF: ajustarlo al ancho de la emision'
    gui_hint: 1,0,1,1
    label: BW DF
    labels: '["1 kHz", "3.1 kHz", "6 kHz", "12 kHz", "15 kHz", "25 kHz", "50 kHz", "120 kHz", "300 kHz", "1 MHz"]'
    num_opts: '0'
    options: '[1e3, 3.1e3, 6e3, 12e3, 15e3, 25e3, 50e3, 120e3, 300e3, 1e6]'
    orient: QtCore.Qt.QVBoxLayout
    type: real
    value: 15e3
  states: {}
- name: meas_time
  id: variable_qtgui_chooser
  parameters:
    comment: Promediado DF. El manual recomienda 0.5 s en movimiento
    gui_hint: 1,1,1,1
    label: Tiempo de medida
    labels: '["0.1 s", "0.2 s", "0.5 s", "1 s", "2 s", "5 s"]'
    num_opts: '0'
    options: '[0.1, 0.2, 0.5, 1.0, 2.0, 5.0]'
    orient: QtCore.Qt.QVBoxLayout
    type: real
    value: '0.5'
  states: {}
- name: df_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,1
    label: Modo DF
    label0: Continuo
    label1: Normal (squelch)
    label2: Gate
    num_opts: '3'
    option0: '"CONT"'
    option1: '"NORM"'
    option2: '"GATE"'
    orient: QtCore.Qt.QVBoxLayout
    type: string
    value: '"CONT"'
  states: {}
- name: em200_df_source_0
  id: em200_df_source
  parameters:
    df_bandwidth: df_bw
    df_mode: df_mode
    freq: freq
    hold_last: 'True'
    ip: 192.168.29.200
    meas_time: meas_time
    port: '5555'
    restore: 'True'
    span: 1e6
    threshold: '10'
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    gui_hint: 2,0,2,1
    min_size: '300'
    name: '"Azimut"'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color2: ("black", "green")
    color3: ("black", "yellow")
    color4: ("red", "green")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,1,1,2
    label1: Azimut
    label2: Calidad
    label3: Nivel
    label4: Valido
    max: '360'
    min: '0'
    name: '"Medida DF"'
    nconnections: '4'
    type: float
    unit1: deg
    unit2: '%'
    unit3: dBuV
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Historico de ~60 s (unas 10 medidas por segundo)
    entags: 'False'
    grid: 'True'
    gui_hint: 3,1,1,2
    label1: Azimut
    label2: Calidad
    marker1: '0'
    name: '"Historico azimut / calidad"'
    nconnections: '2'
    size: '600'
    srate: '10'
    style1: '0'
    type: float
    ylabel: Azimut (deg) / Calidad (%)
    ymax: '360'
    ymin: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Habilitalo para ver en consola cada medida completa (rumbo, GPS, timestamps...)
  states: {state: disabled}

connections:
- [em200_df_source_0, '0', qtgui_compass_0, '0']
- [em200_df_source_0, '0', qtgui_number_sink_0, '0']
- [em200_df_source_0, '1', qtgui_number_sink_0, '1']
- [em200_df_source_0, '2', qtgui_number_sink_0, '2']
- [em200_df_source_0, '3', qtgui_number_sink_0, '3']
- [em200_df_source_0, '0', qtgui_time_sink_x_0, '0']
- [em200_df_source_0, '1', qtgui_time_sink_x_0, '1']
- [em200_df_source_0, df, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
