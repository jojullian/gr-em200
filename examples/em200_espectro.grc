options:
  parameters:
    description: Analizador de espectro con el IQ del R&S EM200 por Ethernet (EB200/TCP).
    generate_options: qt_gui
    id: em200_espectro
    output_language: python
    title: EM200 - Analizador de espectro
  states: {}

blocks:
- name: import_em200
  id: import
  parameters:
    comment: Para usar em200.sample_rate() en las variables
    imports: import em200
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frecuencia (Hz)
    start: 20e6
    step: 100e3
    stop: 8e9
    value: 90.5e6
  states: {}
- name: bw
  id: variable_qtgui_chooser
  parameters:
    comment: Con un enlace de 100 Mb/s el maximo util es 1.25 MHz (1.6 MS/s)
    gui_hint: 1,0,1,1
    label: Ancho de banda
    labels: '["120 kHz (200 kS/s)", "300 kHz (400 kS/s)", "500 kHz (800 kS/s)", "1 MHz (1.6 MS/s)", "1.25 MHz (1.6 MS/s)", "2 MHz (3.2 MS/s, requiere 1 Gb/s)", "5 MHz (6.4 MS/s, requiere 1 Gb/s)"]'
    num_opts: '0'
    options: '[120e3, 300e3, 500e3, 1e6, 1.25e6, 2e6, 5e6]'
    orient: QtCore.Qt.QVBoxLayout
    type: real
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Tasa IQ que entrega el EM200 para el ancho de banda elegido
    value: em200.sample_rate(bw)
  states: {}
- name: em200_iq_source_0
  id: em200_iq_source
  parameters:
    bandwidth: bw
    buffer_seconds: '2.0'
    freq: freq
    if_mode: '"SHORT"'
    ip: 192.168.29.200
    port: '5555'
    restore: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: EM200
    legend: 'False'
    name: '"Espectro EM200"'
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: 3,0,1,2
    int_max: '0'
    legend: 'False'
    name: '"Waterfall EM200"'
    type: complex
  states: {}

connections:
- [em200_iq_source_0, '0', qtgui_freq_sink_x_0, '0']
- [em200_iq_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
